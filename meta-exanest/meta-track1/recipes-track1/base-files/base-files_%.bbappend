# This is basic file customisation

FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"
