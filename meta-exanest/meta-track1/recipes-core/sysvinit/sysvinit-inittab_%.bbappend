# ttyPS0 is the Xilinx PS port.
SERIAL_CONSOLES += "115200;ttyPS0"
