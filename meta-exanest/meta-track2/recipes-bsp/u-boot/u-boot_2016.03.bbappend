# This is

FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-xlnx:"

XILINX_EXTENSION = "-xilinx-iceotope"
